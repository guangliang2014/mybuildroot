## fullsys/Config.in
```kconfig
source "$BR2_EXTERNAL_MY_PATH/package/m4projects/Config.in"
source "$BR2_EXTERNAL_MY_PATH/package/eth-switch/Config.in"
```
